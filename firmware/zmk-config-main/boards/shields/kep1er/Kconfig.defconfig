## firmware/zmk-config-main/boards/shields/kep1er/Kconfig.defconfig
```kconfig
if SHIELD_KEP1ER

config ZMK_KEYBOARD_NAME
    default "(kk)"

endif # SHIELD_KEP1ER
```
